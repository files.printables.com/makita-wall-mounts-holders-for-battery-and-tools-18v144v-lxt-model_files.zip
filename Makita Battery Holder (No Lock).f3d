Makita Battery Holder (No Lock) (Autodesk Fusion 360 design; units mm, degrees)
base_feature "Base Feature" bodies "Makita Battery Holder"
other steps:
create_component "CreateComponent1"
named bodies: "Makita Battery Holder"